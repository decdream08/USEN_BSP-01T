# Keil uVision project Uart_Interrupt.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: Uart_Interrupt +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __NO_EMBEDDED_ASM
  c include: ..\Core\CMSIS\Include;..\Core\Device\ABOV\A31G21x\Include;..\Drivers\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../Core/Device/ABOV/A31G21x/Source/ARM/: startup_A31G21x.s
  group CMSIS-CM0P
    ../Core/Device/ABOV/A31G21x/Source/: system_A31G21x.c
  group Drivers
    ../Drivers/source/: A31G21x_hal_debug_frmwrk.c A31G21x_hal_scu.c A31G21x_hal_pcu.c A31G21x_hal_uartn.c A31G21x_hal_usart1n.c A31G21x_hal_i2c.c A31G21x_hal_timer2n.c A31G21x_hal_timer30.c A31G21x_hal_timer1n.c A31G21x_hal_adc.c A31G21x_hal_wdt.c
  group Main
    ../: main.c A31G21x_it.c A31G21x_PortInit.c A31G21x_SystemClock.c i2c.c dsp_amp.c ir.c user.c serial.c spi.c ADAU1452.c audio_dac.c AD82584F.c timer30.c timer1n.c led_display.c remocon_action.c timer21.c bt_MB3021.c bt_F1DQ3007.c bt_F1DQ3021.c touch_key.c TAS5806MD.c timer20.c flash.c adc.c AD85050.c PCM9211.c power.c adc_polling.c key.c protection.c
    ../G213Lib/: lib_userTimer.lib
